# Keil uVision project Project_DS1307.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project_DS1307 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LCD4bit;.\User
  group Source Group 1
    ./: STARTUP.A51 main.c
